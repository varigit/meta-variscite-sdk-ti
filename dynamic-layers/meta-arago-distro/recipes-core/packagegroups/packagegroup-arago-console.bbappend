ARAGO_SDK_PREREQ:remove:k3 = "ti-rtos-firmware"
