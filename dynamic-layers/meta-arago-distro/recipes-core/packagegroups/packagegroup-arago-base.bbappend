ARAGO_EXTRA:remove += "\
    dropbear \
"
