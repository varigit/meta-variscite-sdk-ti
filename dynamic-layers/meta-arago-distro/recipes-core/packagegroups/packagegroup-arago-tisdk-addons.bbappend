UTILS:remove:k3 = "ti-rtos-firmware"
