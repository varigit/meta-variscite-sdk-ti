FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

RMINITDIR_class-target:remove = "rm_sysvinit_initddir"
