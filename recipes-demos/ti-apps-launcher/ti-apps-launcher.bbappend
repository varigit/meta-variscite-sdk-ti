RDEPENDS:${PN}:remove = " \
    pulseaudio-service \
"
