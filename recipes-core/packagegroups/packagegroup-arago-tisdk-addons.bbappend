DEMOS:remove:am62pxx = "ti-apps-launcher"
