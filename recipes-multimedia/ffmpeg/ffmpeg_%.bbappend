PACKAGECONFIG:append:pn-ffmpeg = " sdl2"
